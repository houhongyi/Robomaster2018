# Keil uVision project SW2812.uvprojx, settings and files
target SW2812 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SW2812
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\UserSource
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group UserSource
    ../UserSource/: MyCom.c SystemState.c WS2812.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c
  group Application/User
    ../Src/: dma.c gpio.c usart.c stm32f1xx_hal_msp.c main.c stm32f1xx_it.c tim.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 4.1.0
